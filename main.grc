options:
  parameters:
    generate_options: qt_gui
    id: main
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 1e6
    stop: 5000e6
    value: 100e6
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.16e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: freq_sweep_output.dat
    type: float
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass MyPythonBlock(gr.sync_block):\n    def __init__(self, center_freq_start=100e6, center_freq_stop=200e6, sample_rate=2.4e6, num_samples=100):\n        gr.sync_block.__init__(\n            self,\n            name='MyPythonBlock',\n            in_sig=[np.complex64],  # Input signal\n            out_sig=[(np.float32, 1), np.complex64]  # Output signals (one for file sink and one for GUI sink)\n        )\n\n        # Define parameters\n        self.center_freq_start = center_freq_start\n        self.center_freq_stop = center_freq_stop\n        self.sample_rate = sample_rate\n        self.num_samples = num_samples  # Added this line\n\n        # Initialize state variables\n        self.current_frequency = center_freq_start\n        self.is_recording = False\n        self.samples_collected = 0  # counter for collected samples\n\n        # MPSK SNR Estimator parameters\n        self.snr_threshold = 10  # Adjust as needed\n\n        # Flag to indicate if end of frequency range has been reached\n        self.end_of_range_reached = False\n\n    def work(self, input_items, output_items):\n        # Check if end of frequency range has been reached\n        if self.end_of_range_reached:\n            # Stop receiving data\n            return 0\n\n        # Perform MPSK SNR estimation\n        signal_power = np.mean(np.abs(input_items[0])**2)\n        noise_power = np.var(input_items[0])\n        snr = 10 * np.log10(signal_power / noise_power)\n\n        # Check if SNR is above the threshold and no sample has been recorded yet\n        if snr > self.snr_threshold and not self.is_recording:\n            self.is_recording = True\n            print(f\"Recording started at frequency: {self.current_frequency}\")\n\n            # Code to start recording goes here\n            # Placeholder: Replace this with actual recording code\n            # Reset samples counter\n            self.samples_collected = 0\n\n        # Check if SNR drops below the threshold and recording is in progress\n        elif snr <= self.snr_threshold and self.is_recording:\n            self.is_recording = False\n            print(f\"Recording stopped at frequency: {self.current_frequency}\")\n\n            # Code to stop recording goes here\n            # Placeholder: Replace this with actual recording code\n\n        # Check if recording is in progress and not enough samples collected\n        if self.is_recording and self.samples_collected < self.num_samples:\n            # Increment samples counter\n            self.samples_collected += len(input_items[0])\n\n        # Move to the next frequency\n        self.current_frequency += self.sample_rate\n\n        # Check if reached the end of frequency range\n        if self.current_frequency > self.center_freq_stop:\n            if not self.end_of_range_reached:\n                print(\"End of frequency range reached.\")\n                self.end_of_range_reached = True\n\n        # Copy input to first output (casting to float32)\n        output_items[0][:] = input_items[0].real.astype(np.float32)\n\n        # Copy input to second output\n        output_items[1][:] = input_items[0]\n\n        # Return the number of samples consumed (same as the input size)\n        return len(input_items[0])\n\n"
    center_freq_start: 88e6
    center_freq_stop: 500e7
    num_samples: '1024'
    sample_rate: 10e4
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [digital_mpsk_snr_est_cc_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_file_sink_0, '0']
- [epy_block_0, '1', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', digital_mpsk_snr_est_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
